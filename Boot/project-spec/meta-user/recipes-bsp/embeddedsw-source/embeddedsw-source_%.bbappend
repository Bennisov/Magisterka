SRC_URI += " file://0001-TE-mods.patch \
             file://git/lib/sw_apps/zynqmp_fsbl/src"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

